# Keil uVision project Flow.uvprojx, settings and files
target Flow (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Flow +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,USE_USB_OTG_FS,STM32F446xx, ARM_MATH_CM4, __FPU_PRESENT = 1
  c misc: --c99
  c include: .\applications;.\build;.\drivers;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\Libraries\CMSIS\Include;.\Libraries\CMSIS\ST\STM32F4xx\Include;.\Libraries\USBStack\INC;.\Libraries\FatFS\src;.\drivers\camera;.\drivers\MPU6050;.\Libraries\VL53L0X\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Applications
    ./applications/: include.h stm32f4xx_conf.h main.c stm32f4xx_it.c init.c init.h version.c loop.c loop.h Drv_vl53l0x.c Drv_vl53l0x.h flow_filter.c flow_filter.h ks_flow.c ks_flow.h dma.c dma.h Lcd_Driver.c Lcd_Driver.h Picture.h LCD_Config.h
  group Camera
    ./drivers/camera/: camera.c camera.h DataExchange.c DataExchange.h ov7670cfg.h ov7740cfg.h sccb.c sccb.h
  group Vl53l0x
    ./Libraries/VL53L0X/src/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c vl53l0x_i2c.c vl53l0x_i2c_soft.c vl53l0x_platform.c
  group MPU6050
    ./drivers/MPU6050/: ANO_Data.c ANO_Data.h ANO_Drv_MPU6050.c ANO_Drv_MPU6050.h ANO_IMU.c ANO_IMU.h ANO_Param.c ANO_Param.h filter.c filter.h i2c_soft.c i2c_soft.h mymath.c mymath.h
  group Drivers
    ./drivers/: time.c time.h dcmi.c dcmi.h key.c key.h led.c led.h pwm.c pwm.h stmflash.c stmflash.h usart.c usart.h
  group Libraries
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_dcmi.c stm32f4xx_spi.c
    ./Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
    ./Libraries/CMSIS/ST/STM32F4xx/Include/: system_stm32f4xx.c
  group Note
    ./doc/: note.txt record.txt
software components: CMSIS:CORE 5.3.0
